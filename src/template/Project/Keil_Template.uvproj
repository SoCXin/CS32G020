# Keil uVision project Keil_Template.uvproj, settings and files
target Keil_Template (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: CS32G020 Chipsea
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x0EFFF) IROM2(0x00100000-0x00100FFF) XROM(0x00300000-0x003001FF) CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Keil_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Misc;..\FWLib\inc;..\BSP\inc;..\User
  library: MicroLIB
  memory RVCT1: ROM 0x300000 size 0x200
  memory RVCT4: ROM 0x0 size 0xf000
  memory RVCT5: ROM 0x100000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Misc
    ../Misc/: startup_CSA36FX30.s
  group FWLib
    ../FWLib/src/: CSA36FX30_FW.lib
  group User
    ../User/: csa36fx30_it.c main.c system_csa36fx30.c
